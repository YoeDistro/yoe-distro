OS_RELEASE_FIELDS_append = " HOME_URL SUPPORT_URL BUG_REPORT_URL"
HOME_URL = "http://bec-systems.com"
SUPPORT_URL = "http://bec-systems.com/support"
BUG_REPORT_URL = "https://github.com/cbrake/meta-bec/issues"
