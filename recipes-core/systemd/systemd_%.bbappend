PACKAGECONFIG_append = " resolved networkd "
