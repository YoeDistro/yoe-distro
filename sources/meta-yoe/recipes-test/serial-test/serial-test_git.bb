DESCRIPTION = "Serial test application"
HOMEPAGE = "https://github.com/cbrake/linux-serial-test"
SECTION = "utils"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.MIT;md5=544799d0b492f119fa04641d1b8868ed"
SRCREV = "1a81f3c7be086ee01a9be8589a606426276c86d5"

SRC_URI = "git://github.com/cbrake/linux-serial-test.git;branch=master;protocol=https"

inherit cmake

