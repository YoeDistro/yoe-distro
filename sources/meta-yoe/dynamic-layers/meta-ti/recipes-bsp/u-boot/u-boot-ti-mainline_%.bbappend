FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-ti-mmc-Load-kernel-and-fdt-from-FAT-parition.patch"
