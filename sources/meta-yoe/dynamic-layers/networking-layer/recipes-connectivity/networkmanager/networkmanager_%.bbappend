PACKAGECONFIG:remove = "ifupdown readline"
PACKAGECONFIG:append = " libedit"
