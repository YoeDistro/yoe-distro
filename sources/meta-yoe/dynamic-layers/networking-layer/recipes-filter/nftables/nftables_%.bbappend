# Avoid readline and libgmp linking in
PACKAGECONFIG = "editline json mini-gmp python"
