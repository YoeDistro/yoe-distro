# Do not install wg-quick, avoids bash in image
PACKAGECONFIG = ""
