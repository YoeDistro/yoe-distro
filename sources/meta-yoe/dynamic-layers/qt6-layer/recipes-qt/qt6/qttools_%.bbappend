# Disable the optional clang integration for native qttools
PACKAGECONFIG:remove:class-native = "clang"
