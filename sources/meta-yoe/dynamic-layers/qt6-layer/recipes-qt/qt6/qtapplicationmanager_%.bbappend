FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-common-lib-link-zlib-directly-instead-of-relying-on-.patch"
