# Pin to a version that works with kernel 5.15 kernel
# which is used on older variscite MX8 machines
# see https://github.com/Freescale/meta-freescale/pull/1611#issuecomment-1656991351
SRCREV = "8c864975607cf455c5e95d5313aa00e69f48d32f"
