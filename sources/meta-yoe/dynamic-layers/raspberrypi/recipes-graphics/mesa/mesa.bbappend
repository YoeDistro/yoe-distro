# mesa 25.x removed it
PACKAGECONIG:remove:rpi = "kmsro"
