FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES:yoe = "file://psplash-yoe.png;outsuffix=default"
