FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://yoe_fragment.cfg"
