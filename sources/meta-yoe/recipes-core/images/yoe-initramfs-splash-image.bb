require yoe-initramfs-image.bb

IMAGE_FEATURES = "splash"

export IMAGE_BASENAME = "yoe-initramfs-splash-image"
