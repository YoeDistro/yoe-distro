require initramfs-image.bb

IMAGE_FEATURES = "splash"

export IMAGE_BASENAME = "initramfs-image-splash"
