ALTERNATIVE_LINK_NAME[findfs] = "${sbindir}/findfs"
