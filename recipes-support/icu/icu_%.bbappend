FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

PARALLEL_MAKE = ""

